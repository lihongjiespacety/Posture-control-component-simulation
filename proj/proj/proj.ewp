# IAR project proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CSP_FREERTOS
  ICCARM.CCIncludePath2: ..\src\App; ..\src\App\dev_protocal; ..\src\FreeRTOS\; ..\src\FreeRTOS\include\; ..\src\FreeRTOS\portable\IAR\; ..\src\STM32F10x_StdPeriph_Lib_V3.5.0\; ..\src\STM32F10x_StdPeriph_Lib_V3.5.0\CMSIS\CM3\CoreSupport\; ..\src\STM32F10x_StdPeriph_Lib_V3.5.0\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\src\STM32F10x_StdPeriph_Lib_V3.5.0\STM32F10x_StdPeriph_Driver\inc\; ..\src\libcsp-master\include\; ..\src\libcsp-master\include\csp\arch\; ..\src\libcsp-master\include\csp\drivers\; ..\src\libcsp-master\include\csp\interfaces\; ..\src\libcsp-master\include\csp\; ..\src\libcsp-master\include\csp\interfaces\; ..\src\libcsp-master\src\crypto\; ..\src\libcsp-master\src\transport\; ..\src\libcsp-master\src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\FreeRTOS\
  OBJCOPY.OOCOutputFile: libcsp_libuv_freertos.srec
  ILINK.IlinkOutputFile: libcsp_libuv_freertos.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: README.txt
  group App
    ../src/App/: bsp.c bsp.h bsp_sci.c bsp_sci.h bsp_time.c bsp_time.h cantxrxtask.c cantxrxtask.h clock.c clock.h common.c common.h driver.c driver.h driver_can.c driver_can.h driver_time.c driver_time.h driver_uart.c driver_uart.h hal.c hal.h hal_uart.c hal_uart.h main.c osapi_freertos.c osapi_freertos.h retarget.c retarget.h shell.c shell.h shell_fun.c shell_fun.h
  group App/dev_protocal
    ../src/App/dev_protocal/: dev_gps.c dev_gps.h dev_gyro.c dev_gyro.h dev_magtm.c dev_magtm.h dev_ssoc.c dev_ssoc.h dev_starsensor.c dev_starsensor.h dev_wheel.c dev_wheel.h obc_protocal.c obc_protocal.h pc_protocal.c pc_protocal.h
  group FreeRTOS
    ../src/FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../src/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/MemMang
    ../src/FreeRTOS/portable/MemMang/: heap_3.c heap_4.c
  group FreeRTOS/portable
    ../src/FreeRTOS/portable/IAR/: port.c portasm.s portmacro.h
  group libcsp-master/examples
    ../src/libcsp-master/examples/: csp_if_fifo.c csp_if_fifo_windows.c kiss.c simple.c
  group libcsp-master/include/csp
    ../src/libcsp-master/include/csp/: csp.h csp_autoconfig.h csp_buffer.h csp_cmp.h csp_crc32.h csp_debug.h csp_endian.h csp_error.h csp_iflist.h csp_interface.h csp_platform.h csp_rtable.h csp_types.h
  group libcsp-master/include/csp/arch
    ../src/libcsp-master/include/csp/arch/: csp_clock.h csp_malloc.h csp_queue.h csp_semaphore.h csp_system.h csp_thread.h csp_time.h
  group libcsp-master/include/csp/drivers
    ../src/libcsp-master/include/csp/drivers/: can.h i2c.h usart.h
  group libcsp-master/include/csp/interfaces
    ../src/libcsp-master/include/csp/interfaces/: csp_if_can.h csp_if_i2c.h csp_if_kiss.h csp_if_lo.h csp_if_zmqhub.h
  group libcsp-master/src
    ../src/libcsp-master/src/: csp_bridge.c csp_buffer.c csp_conn.c csp_conn.h csp_crc32.c csp_debug.c csp_dedup.c csp_dedup.h csp_endian.c csp_iflist.c csp_io.c csp_io.h csp_port.c csp_port.h csp_promisc.c csp_promisc.h csp_qfifo.c csp_qfifo.h csp_route.c csp_route.h csp_service_handler.c csp_services.c csp_sfp.c
  group libcsp-master/src/arch/freertos
    ../src/libcsp-master/src/arch/freertos/: csp_malloc.c csp_queue.c csp_semaphore.c csp_system.c csp_thread.c csp_time.c
  group libcsp-master/src/crypto
    ../src/libcsp-master/src/crypto/: csp_hmac.c csp_hmac.h csp_sha1.c csp_sha1.h csp_xtea.c csp_xtea.h
  group libcsp-master/src/interfaces
    ../src/libcsp-master/src/interfaces/: can.c csp_if_can.c csp_if_i2c.c csp_if_kiss.c csp_if_lo.c csp_if_zmqhub.c
  group libcsp-master/src/rtable
    ../src/libcsp-master/src/rtable/: csp_rtable_cidr.c csp_rtable_static.c
  group libcsp-master/src/transport
    ../src/libcsp-master/src/transport/: csp_rdp.c csp_transport.h csp_udp.c
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/: stm32f10x_conf.h
  group STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/CoreSupport
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/inc
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_map.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/src
    ../src/STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
